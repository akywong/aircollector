# Keil uVision project aircollector.uvprojx, settings and files
target STM32F103 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: aircollector
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\APP;.\CORE;.\HARDWARE\24CXX;.\HARDWARE\BEEP;.\HARDWARE\BME280;.\STM32F10x_FWLib\inc;.\SYSTEM\delay;.\SYSTEM\sys;.\HARDWARE\IO;.\HARDWARE\IO_IIC;.\HARDWARE\IO_SPI;.\HARDWARE\LED;.\HARDWARE\RTC;.\HARDWARE\SPI;.\HARDWARE\TimerPWM;.\HARDWARE\TIMER;.\HARDWARE\USART;.\HARDWARE\W25QXX;.\MODULES\FATFS\src;.\HARDWARE\SDIO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/: system_stm32f10x.c stm32f10x_it.c main.c
  group HARDWARE
    ./HARDWARE/24CXX/: 24cxx.c
    ./HARDWARE/BEEP/: beep.c
    ./HARDWARE/BME280/: bme280.c bme_spi.c
    ./HARDWARE/IO/: io.c
    ./HARDWARE/IO_SPI/: iospi.c
    ./HARDWARE/LED/: led.c
    ./HARDWARE/RTC/: rtc.c
    ./HARDWARE/SPI/: spi.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/TimerPWM/: TimerPWM.c
    ./HARDWARE/USART/: usart.c
    ./HARDWARE/SDIO/: sdio_sdcard.c
    ./HARDWARE/IO_IIC/: ioiic.c
  group LIB
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
  group MODULES
    ./MODULES/FATFS/src/: diskio.c ff.c
    ./MODULES/FATFS/src/option/: unicode.c
